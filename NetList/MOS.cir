.include TSMC_180nm.txt
VGS G gnd 1.8V
VDS D gnd 1.8V
M1 D G gnd gnd CMOSN W=1.8u L=0.18u
.dc VGS 0 1.8 0.005
.control
run
plot -VDS#branch
.endc
